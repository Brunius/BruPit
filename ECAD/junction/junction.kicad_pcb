# Repository Brunius/BruPit

File README.md:

# BruPit

A flight simulator project.

BruPit started because I went _"Gosh, Cougar MFDs are expensive for what you get"_. Since then it's grown, much more than I expected it to. I never expected to need to do proper software engineer stuff like sequence diagrams and READMEs. This repository is organised as best I can; I think it's fairly clear where stuff is, but I may be wrong. In short:

## ECAD

Contains _electrical_ CAD items. These are Circuit Diagrams and PCB layouts. All items are designed with kicad.

## MCAD

Contains _mechanical_ CAD items. These are mostly enclosures for stuff. All items are designed with Solidworks (sorry, FreeCAD - I love you, but I really wanted an assembly workbench).

## Programs

Contains the software you need. These are intended to be loaded using the Arduino IDE, though other IDEs may work.

## Documentation

Contains any documentation, mostly surrounding the software. This is stuff you _shouldn't_ need as a home user, but might want if you're modifying the software.

For any further questions or queries, you can contact me at brunius@brunius.me or Brunius#5625 on Discord.

## KiCad design ECAD/junction/junction.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
H5: MountingHole; MountingHole_4.3mm_M4
J1, J2, J3, J4: Conn_01x04; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal

Connections:
+5V: J1.1, J2.1, J3.1, J4.1
GND: J1.4, J2.4, J3.4, J4.4
SCL: J1.2, J2.2, J3.2, J4.2
SDA: J1.3, J2.3, J3.3, J4.3

Board: 2 copper layers, 24.0 x 24.0 mm, 9 parts (0 on the bottom side), 4 nets.

## KiCad design ECAD/MFDintbutton/MFDintbutton.kicad_pcb

Parts:
C1: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
F1: Polyfuse; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J2, J3: Conn_01x04; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
JP1, JP2, JP3: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R1, R2, R3, R4, R5: 330; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
RV1, RV2, RV3, RV4: R_POT; Potentiometer_Alpha_RD901F-40-00D_Single_Vertical
SW11, SW12, SW13, SW14, SW21, SW22, SW23, SW24, SW31, SW32, SW33, SW34, SW41, SW42, SW43, SW44: SW_Push; SW_Cherry_MX_1.00u_PCB
U1: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm

Connections:
+5V: D1.2 (A), F1.1, J1.2, RV1.1, RV2.1, RV3.1, RV4.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC)
/1line: JP1.1, U1.12 (PB0)
/2line: JP2.1, U1.13 (PB1)
/4line: JP3.1, U1.14 (PB2)
/COL1: SW11.2, SW12.2, SW13.2, SW14.2, U1.32 (PD2)
/COL2: SW21.2, SW22.2, SW23.2, SW24.2, U1.31 (PD1)
/COL3: SW31.2, SW32.2, SW33.2, SW34.2, U1.30 (PD0)
/COL4: SW41.2, SW42.2, SW43.2, SW44.2, U1.11 (PD7)
/ROW1: SW11.1, SW21.1, SW31.1, SW41.1, U1.1 (PD3)
/ROW2: SW12.1, SW22.1, SW32.1, SW42.1, U1.2 (PD4)
/ROW3: SW13.1, SW23.1, SW33.1, SW43.1, U1.9 (PD5)
/ROW4: SW14.1, SW24.1, SW34.1, SW44.1, U1.10 (PD6)
A0: RV4.2, U1.23 (PC0)
A1: RV3.2, U1.24 (PC1)
A2: RV1.2, U1.25 (PC2)
A3: RV2.2, U1.26 (PC3)
GND: C1.2, J1.6, J2.4, J3.4, JP1.2, JP2.2, JP3.2, R1.2, R2.2, R3.2, R4.2, R5.1, U1.3 (GND), U1.5 (GND), U1.21 (GND)
MISO: J1.1, U1.16 (PB4)
MOSI: J1.4, U1.15 (PB3)
unnamed: C1.1, U1.20 (AREF)
unnamed: D1.1 (K), R5.2
unnamed: F1.2, J2.1, J3.1
unnamed: R1.1, RV1.3
unnamed: R2.1, RV2.3
unnamed: R3.1, RV3.3
unnamed: R4.1, RV4.3
RESET: J1.5, U1.29 (~RESET~/PC6)
SCK: J1.3, U1.17 (PB5)
SCL: J2.2, J3.2, U1.28 (PC5)
SDA: J2.3, J3.3, U1.27 (PC4)

Notes on the sheet:
RV-09 potentiometer (4c/unit on aliexpress)

Board: 2 copper layers, 109.0 x 109.0 mm, 35 parts (0 on the bottom side), 30 nets.

## KiCad design ECAD/i2c-master/i2c-master.kicad_pcb

Board: 2 copper layers, 49.9 x 36.8 mm, 18 parts (1 on the bottom side), 23 nets.

Parts:
5V: Jumper_NC_Dual; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm_NumberLabels
C1: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
H1, H2, H4: MountingHole; MountingHole_3.2mm_M3_ISO7380
J1, J6: Conn_01x12_Female; PinSocket_1x12_P2.54mm_Vertical
J2, J3, J4, J5, J7, J8, J9, J10: Conn_01x04; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J11: Barrel_Jack; BarrelJack_Horizontal
J12: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Horizontal
U1: L7805; TO-220-3_Horizontal_TabDown

Connections:
!IO3-SCL: J1.6, J2.2, J3.2, J4.2, J5.2, J7.2, J8.2, J9.2, J10.2, J12.7
!IO5: J1.8, J12.11
!IO6-A7: J1.9, J12.13
!IO9-A9: J1.12, J12.2
!IO10-A10: J6.12, J12.4
+5V: 5V.2, J2.1, J3.1, J4.1, J5.1, J7.1, J8.1, J9.1, J10.1
GND: C1.2, J1.3, J1.4, J2.4, J3.4, J4.4, J5.4, J6.2, J7.4, J8.4, J9.4, J10.4, J11.2, J11.3, J12.20, U1.2
IO0-RX: J1.2, J12.1
IO1-TX: J1.1, J12.3
IO2-SDA: J1.5, J2.3, J3.3, J4.3, J5.3, J7.3, J8.3, J9.3, J10.3, J12.5
IO4-A6: J1.7, J12.9
IO7: J1.10, J12.15
IO8-A8: J1.11, J12.17
IO14-MISO: J6.10, J12.6
IO15-SCK: J6.9, J12.8
IO16-MOSI: J6.11, J12.10
IO18-A0: J6.8, J12.12
IO19-A1: J6.7, J12.14
IO20-A2: J6.6, J12.16
IO21-A3: J6.5, J12.18
unnamed: 5V.3, C1.1, U1.3
VCC: 5V.1, J6.4, J12.19
VIN: J6.1, J11.1, U1.1

## KiCad design ECAD/MFD-child/MFD-child.kicad_pcb

Parts:
Atmega328P-AU1: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
C4: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1: LED; LED_1206_3216Metric_Castellated
F1: Polyfuse; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: ICSP; PinHeader_2x03_P2.54mm_Vertical
J2, J3: Conn_01x04; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
JP1, JP2, JP3: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R1: 10K; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
R5, R8: 330; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
SW1: RESET; SW_DIP_SPSTx01_Slide_6.7x4.1mm_W8.61mm_P2.54mm_LowProfile
SW2: SW_Coded_SH-7010; Nidec_Copal_SH-7010B
SW11: OSB1; SW_SPST_PTS645
SW12: OSB2; SW_SPST_PTS645
SW13: OSB3; SW_SPST_PTS645
SW14: OSB4; SW_SPST_PTS645
SW15: OSB5; SW_SPST_PTS645
SW16: SYM-UP; SW_SPST_PTS645
SW17: SYM-DN; SW_SPST_PTS645
SW21: OSB6; SW_SPST_PTS645
SW22: OSB7; SW_SPST_PTS645
SW23: OSB8; SW_SPST_PTS645
SW24: OSB9; SW_SPST_PTS645
SW25: OSB10; SW_SPST_PTS645
SW26: CON-UP; SW_SPST_PTS645
SW27: CON-DN; SW_SPST_PTS645
SW31: OSB11; SW_SPST_PTS645
SW32: OSB12; SW_SPST_PTS645
SW33: OSB13; SW_SPST_PTS645
SW34: OSB14; SW_SPST_PTS645
SW35: OSB15; SW_SPST_PTS645
SW36: BRT-UP; SW_SPST_PTS645
SW37: BRT-DN; SW_SPST_PTS645
SW41: OSB16; SW_SPST_PTS645
SW42: OSB17; SW_SPST_PTS645
SW43: OSB18; SW_SPST_PTS645
SW44: OSB19; SW_SPST_PTS645
SW45: OSB20; SW_SPST_PTS645
SW46: GAIN-UP; SW_SPST_PTS645
SW47: GAIN-DN; SW_SPST_PTS645

Connections:
+5V: Atmega328P-AU1.4 (VCC), Atmega328P-AU1.6 (VCC), Atmega328P-AU1.18 (AVCC), D1.2 (A), F1.2, J1.2, R1.2
/1line: Atmega328P-AU1.12 (PB0), JP1.1
/2line: Atmega328P-AU1.13 (PB1), JP2.1
/4line: Atmega328P-AU1.14 (PB2), JP3.1
BUS_SIGNAL: Atmega328P-AU1.30 (PD0)
C1: Atmega328P-AU1.23 (PC0), SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, SW16.2, SW17.2
C2: Atmega328P-AU1.24 (PC1), SW21.2, SW22.2, SW23.2, SW24.2, SW25.2, SW26.2, SW27.2
C3: Atmega328P-AU1.25 (PC2), SW31.2, SW32.2, SW33.2, SW34.2, SW35.2, SW36.2, SW37.2
C4: Atmega328P-AU1.26 (PC3), SW41.2, SW42.2, SW43.2, SW44.2, SW45.2, SW46.2, SW47.2
GNDREF: Atmega328P-AU1.3 (GND), Atmega328P-AU1.5 (GND), Atmega328P-AU1.21 (GND), C4.2, J1.6, J2.4, J3.4, JP1.2, JP2.2, JP3.2, R5.2, R8.1, SW2.4, SW2.8, SW2.C
MISO: Atmega328P-AU1.16 (PB4), J1.1
MOSI: Atmega328P-AU1.15 (PB3), J1.4
unnamed: Atmega328P-AU1.7 (XTAL1/PB6), SW2.1
unnamed: Atmega328P-AU1.8 (XTAL2/PB7), SW2.2
unnamed: Atmega328P-AU1.20 (AREF), C4.1
unnamed: D1.1 (K), R8.2
unnamed: F1.1, J2.1, J3.1
unnamed: R5.1, SW1.1
R1: Atmega328P-AU1.31 (PD1), SW11.1, SW21.1, SW31.1, SW41.1
R2: Atmega328P-AU1.32 (PD2), SW12.1, SW22.1, SW32.1, SW42.1
R3: Atmega328P-AU1.1 (PD3), SW13.1, SW23.1, SW33.1, SW43.1
R4: Atmega328P-AU1.2 (PD4), SW14.1, SW24.1, SW34.1, SW44.1
R5: Atmega328P-AU1.9 (PD5), SW15.1, SW25.1, SW35.1, SW45.1
R6: Atmega328P-AU1.10 (PD6), SW16.1, SW26.1, SW36.1, SW46.1
R7: Atmega328P-AU1.11 (PD7), SW17.1, SW27.1, SW37.1, SW47.1
RESET: Atmega328P-AU1.29 (~RESET~/PC6), J1.5, R1.1, SW1.2
SCK: Atmega328P-AU1.17 (PB5), J1.3
SCL: Atmega328P-AU1.28 (PC5), J2.2, J3.2
SDA: Atmega328P-AU1.27 (PC4), J2.3, J3.3

Board: 2 copper layers, 136.2 x 158.7 mm, 43 parts (2 on the bottom side), 28 nets.

## KiCad design ECAD/MFDint-option2/MFDint-option2-RHS.kicad_pcb

Board: 2 copper layers, 53.5 x 109.0 mm, 29 parts (0 on the bottom side), 28 nets.

Parts:
C2: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D2: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D11, D12, D13, D21, D22, D23: D; D_SOD-123
F2: Polyfuse; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H3, H4: MountingHole; MountingHole_4.3mm_M4
H9, H10, H11, H12: MountingHole; MountingHole_3.2mm_M3
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J5, J6: Conn_01x04; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
JP4, JP5, JP6: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R1: 330; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
TOG11, TOG12, TOG13, TOG21, TOG22, TOG23: SW_SPDT_MSM; SPDT-CentreOff
U2: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm

Connections:
/1line2: JP4.1, U2.12
/2line2: JP5.1, U2.13
/4line2: JP6.1, U2.14
/COL12: D11.2, D12.2, D13.2, U2.31
/COL22: D21.2, D22.2, D23.2, U2.30
/ROW12: TOG11.3, TOG21.3, U2.32
/ROW22: TOG11.1, TOG21.1, U2.1
/ROW32: TOG12.3, TOG22.3, U2.2
/ROW42: TOG12.1, TOG22.1, U2.9
/ROW52: TOG13.3, TOG23.3, U2.10
/ROW62: TOG13.1, TOG23.1, U2.11
GNDREF: C2.2, J4.6, J5.4, J6.4, JP4.2, JP5.2, JP6.2, R1.2, U2.3, U2.5, U2.21
MISO2: J4.1, U2.16
MOSI2: J4.4, U2.15
unnamed: C2.1, U2.20
unnamed: D2.1, R1.1
unnamed: D11.1, TOG11.2
unnamed: D12.1, TOG12.2
unnamed: D13.1, TOG13.2
unnamed: D21.1, TOG21.2
unnamed: D22.1, TOG22.2
unnamed: D23.1, TOG23.2
unnamed: F2.2, J5.1, J6.1
RESET2: J4.5, U2.29
SCK2: J4.3, U2.17
SCL2: J5.2, J6.2, U2.28
SDA2: J5.3, J6.3, U2.27
VCC: D2.2, F2.1, J4.2, U2.4, U2.6, U2.18

## KiCad design ECAD/MFD-panel2/MFD-panel2.kicad_pcb

Board: 2 copper layers, 136.2 x 158.7 mm, 84 parts (1 on the bottom side), 61 nets.

Parts:
ATMEGA328P-AU, ATMEGA328P-AU#2: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
Atmega328P-AU1: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
C1, C2, C4: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1: LED; LED_1206_3216Metric_Castellated
D1#2, D2: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D11, D12, D13, D21, D22, D23: D; D_SOD-123
J1: ICSP; PinHeader_2x03_P2.54mm_Vertical
J1#2, J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J2, J2#2, J3, J5, J6: Conn_01x04; PinHeader_1x04_P2.54mm_Horizontal_SMD
JP1, JP1#2, JP2, JP2#2, JP3, JP3#2, JP4, JP5, JP6: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R1: 10K; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
R1#2, R5#2: 330; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R5, R8: 330; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
SW1: RESET; SW_DIP_SPSTx01_Slide_6.7x4.1mm_W8.61mm_P2.54mm_LowProfile
SW2: SW_Coded_SH-7010; Nidec_Copal_SH-7010B
SW11: OSB1; SW_SPST_PTS645
SW11#2, SW12#2, SW13#2, SW14#2, SW21#2, SW22#2, SW23#2, SW24#2: SW_Push; SW_Cherry_MX_1.00u_PCB
SW12: OSB2; SW_SPST_PTS645
SW13: OSB3; SW_SPST_PTS645
SW14: OSB4; SW_SPST_PTS645
SW15: OSB5; SW_SPST_PTS645
SW16: SYM-UP; SW_SPST_PTS645
SW17: SYM-DN; SW_SPST_PTS645
SW21: OSB6; SW_SPST_PTS645
SW22: OSB7; SW_SPST_PTS645
SW23: OSB8; SW_SPST_PTS645
SW24: OSB9; SW_SPST_PTS645
SW25: OSB10; SW_SPST_PTS645
SW26: CON-UP; SW_SPST_PTS645
SW27: CON-DN; SW_SPST_PTS645
SW31: OSB11; SW_SPST_PTS645
SW32: OSB12; SW_SPST_PTS645
SW33: OSB13; SW_SPST_PTS645
SW34: OSB14; SW_SPST_PTS645
SW35: OSB15; SW_SPST_PTS645
SW36: BRT-UP; SW_SPST_PTS645
SW37: BRT-DN; SW_SPST_PTS645
SW41: OSB16; SW_SPST_PTS645
SW42: OSB17; SW_SPST_PTS645
SW43: OSB18; SW_SPST_PTS645
SW44: OSB19; SW_SPST_PTS645
SW45: OSB20; SW_SPST_PTS645
SW46: GAIN-UP; SW_SPST_PTS645
SW47: GAIN-DN; SW_SPST_PTS645
TOG11, TOG12, TOG13, TOG21, TOG22, TOG23: SW_SPDT_MSM; SPDT-CentreOff
mouse-bite-2mm-slot, mouse-bite-2mm-slot#2, mouse-bite-2mm-slot#3: VAL**; mouse-bite-2mm-slot-5mm-width

Connections:
+5V: ATMEGA328P-AU#2.4, ATMEGA328P-AU#2.6, ATMEGA328P-AU#2.18, Atmega328P-AU1.4, Atmega328P-AU1.6, Atmega328P-AU1.18, D1.2, D1#2.2, J1.2, J1#2.2, J2.1, J2#2.1, J3.1, R1.2
/1line: ATMEGA328P-AU#2.12, Atmega328P-AU1.12, JP1.1, JP1#2.1
/1line2: ATMEGA328P-AU.12, JP4.1
/2line: ATMEGA328P-AU#2.13, Atmega328P-AU1.13, JP2.1, JP2#2.1
/2line2: ATMEGA328P-AU.13, JP5.1
/4line: ATMEGA328P-AU#2.14, Atmega328P-AU1.14, JP3.1, JP3#2.1
/4line2: ATMEGA328P-AU.14, JP6.1
/COL1: ATMEGA328P-AU#2.32, SW11#2.2, SW12#2.2, SW13#2.2, SW14#2.2
/COL2: ATMEGA328P-AU#2.31, SW21#2.2, SW22#2.2, SW23#2.2, SW24#2.2
/COL12: ATMEGA328P-AU.31, D11.2, D12.2, D13.2
/COL22: ATMEGA328P-AU.30, D21.2, D22.2, D23.2
/ROW1: ATMEGA328P-AU#2.1, SW11#2.1, SW21#2.1
/ROW2: ATMEGA328P-AU#2.2, SW12#2.1, SW22#2.1
/ROW3: ATMEGA328P-AU#2.9, SW13#2.1, SW23#2.1
/ROW4: ATMEGA328P-AU#2.10, SW14#2.1, SW24#2.1
/ROW12: ATMEGA328P-AU.32, TOG11.3, TOG21.3
/ROW22: ATMEGA328P-AU.1, TOG11.1, TOG21.1
/ROW32: ATMEGA328P-AU.2, TOG12.3, TOG22.3
/ROW42: ATMEGA328P-AU.9, TOG12.1, TOG22.1
/ROW52: ATMEGA328P-AU.10, TOG13.3, TOG23.3
/ROW62: ATMEGA328P-AU.11, TOG13.1, TOG23.1
C1: Atmega328P-AU1.23, SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, SW16.2, SW17.2
C2: Atmega328P-AU1.24, SW21.2, SW22.2, SW23.2, SW24.2, SW25.2, SW26.2, SW27.2
C3: Atmega328P-AU1.25, SW31.2, SW32.2, SW33.2, SW34.2, SW35.2, SW36.2, SW37.2
C4: Atmega328P-AU1.26, SW41.2, SW42.2, SW43.2, SW44.2, SW45.2, SW46.2, SW47.2
GND: ATMEGA328P-AU#2.3, ATMEGA328P-AU#2.5, ATMEGA328P-AU#2.21, C1.2, J1#2.6, J2#2.4, J3.4, JP1#2.2, JP2#2.2, JP3#2.2, R5#2.2
GNDREF: ATMEGA328P-AU.3, ATMEGA328P-AU.5, ATMEGA328P-AU.21, Atmega328P-AU1.3, Atmega328P-AU1.5, Atmega328P-AU1.21, C2.2, C4.2, J1.6, J2.4, J4.6, J5.4, J6.4, JP1.2, JP2.2, JP3.2, JP4.2, JP5.2, JP6.2, R1#2.2, R5.2, R8.1, SW2.4, SW2.8, SW2.C
MISO: ATMEGA328P-AU#2.16, Atmega328P-AU1.16, J1.1, J1#2.1
MISO2: ATMEGA328P-AU.16, J4.1
MOSI: ATMEGA328P-AU#2.15, Atmega328P-AU1.15, J1.4, J1#2.4
MOSI2: ATMEGA328P-AU.15, J4.4
unnamed: Atmega328P-AU1.7, SW2.1
unnamed: Atmega328P-AU1.8, SW2.2
unnamed: Atmega328P-AU1.20, C4.1
unnamed: ATMEGA328P-AU#2.20, C1.1
unnamed: ATMEGA328P-AU.20, C2.1
unnamed: D1.1, D1#2.1, R5#2.1, R8.2
unnamed: D2.1, R1#2.1
unnamed: D11.1, TOG11.2
unnamed: D12.1, TOG12.2
unnamed: D13.1, TOG13.2
unnamed: D21.1, TOG21.2
unnamed: D22.1, TOG22.2
unnamed: D23.1, TOG23.2
unnamed: R5.1, SW1.1
R1: Atmega328P-AU1.31, SW11.1, SW21.1, SW31.1, SW41.1
R2: Atmega328P-AU1.32, SW12.1, SW22.1, SW32.1, SW42.1
R3: Atmega328P-AU1.1, SW13.1, SW23.1, SW33.1, SW43.1
R4: Atmega328P-AU1.2, SW14.1, SW24.1, SW34.1, SW44.1
R5: Atmega328P-AU1.9, SW15.1, SW25.1, SW35.1, SW45.1
R6: Atmega328P-AU1.10, SW16.1, SW26.1, SW36.1, SW46.1
R7: Atmega328P-AU1.11, SW17.1, SW27.1, SW37.1, SW47.1
RESET: ATMEGA328P-AU#2.29, Atmega328P-AU1.29, J1.5, J1#2.5, R1.1, SW1.2
RESET2: ATMEGA328P-AU.29, J4.5
SCK: ATMEGA328P-AU#2.17, Atmega328P-AU1.17, J1.3, J1#2.3
SCK2: ATMEGA328P-AU.17, J4.3
SCL: ATMEGA328P-AU#2.28, Atmega328P-AU1.28, J2.2, J2#2.2, J3.2
SCL2: ATMEGA328P-AU.28, J5.2, J6.2
SDA: ATMEGA328P-AU#2.27, Atmega328P-AU1.27, J2.3, J2#2.3, J3.3
SDA2: ATMEGA328P-AU.27, J5.3, J6.3
VCC: ATMEGA328P-AU.4, ATMEGA328P-AU.6, ATMEGA328P-AU.18, D2.2, J4.2, J5.1, J6.1

## Commit log

2021-07-14 Actual initial commit
2021-07-14 Quick testerino
2021-07-14 README update
2021-07-14 Final change to README...for now
2021-07-14 Gitignore
2021-07-14 Sequence Diagram, first pass
2021-07-15 Minor documentation update
2021-07-22 Removing panelisations, adding polyfuses
2021-08-11 ECAD updates
2021-08-11 MCAD updates
2021-08-12 Updated gitignore to ignore zips
2021-08-12 Change from 1x04 2.54mm headers to 1x05 micro JST
2021-08-12 Add JST connector and FTDI connector to MFD-child. Also, fix some submodule issues?
2021-08-17 Swap bus connector to 4-pin JST-GH
2021-08-17 Whoops, forgot the master board
2021-08-20 5-pin -> 4-pin JST
2021-08-22 Initial commit of programs.
2022-02-04 major update, MCAD and some programs
2022-02-06 Updates given laser cutting realities
